# Keil uVision project BD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c gps_module.h gps_module.c
    D:/EIE design experience/lcd/: Delay.c Delay.h LCD1602.c LCD1602.h
